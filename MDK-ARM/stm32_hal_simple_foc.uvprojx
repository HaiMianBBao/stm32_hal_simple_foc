# Keil uVision project stm32_hal_simple_foc.uvprojx, settings and files
target stm32_hal_simple_foc (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32_hal_simple_foc +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../lg/debug;../lg;../CherryUSB/class/cdc;../CherryUSB/common;../CherryUSB/core;../CherryUSB;../lg/lgfoc/src/communication;../lg/lgfoc/src/common/base_classes;../lg/lgfoc/src/common;../lg/lgfoc/src/current_sense;../lg/lgfoc/src/sensors;../lg/lgfoc/src;../lg/lgfoc/src/drivers;../lg/port;..\lg\example
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group lg
    ../lg/debug/: dtostrf.c itoa.c Print.cpp Serial.cpp Stream.cpp WString.cpp
    ../lg/lgfoc/src/communication/: Commander.cpp SimpleFOCDebug.cpp
    ../lg/lgfoc/src/: BLDCMotor.cpp
    ../lg/lgfoc/src/drivers/: BLDCDriver3PWM.cpp
    ../lg/lgfoc/src/common/base_classes/: FOCMotor.cpp CurrentSense.cpp Sensor.cpp
    ../lg/lgfoc/src/common/: lowpass_filter.cpp foc_utils.cpp pid.cpp time_utils.cpp
  group port
    ../lg/port/: SerialUart.cpp gpio.cpp delay.cpp pwm.cpp
    ../lg/: MagneticSensorI2C.cpp
  group example
    ../lg/example/: example_main.cpp example.cpp open_loop_position_example.cpp open_loop_velocity_example.cpp
software components: CMSIS:CORE 5.6.0
